# Keil uVision project CANtoPWM.uvprojx, settings and files
target CANtoPWM (5060960::V5.06 update 7 (build 960)::.\ArmCompiler506)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CANtoPWM +hex
  AfterMake: E:\MyApp\Keil\Program\ARM\ArmCompiler506\bin64\fromelf.exe --bin -o .\CANtoPWM\CANtoPWM.bin .\CANtoPWM\CANtoPWM.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: canard.c canard_dynamic_node_id_client.c main.c gpio.c can.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c app_logic.c bootloader.c bootloader_can.c
    ../Core/include/uavcan/equipment/actuator/: actuator_ArrayCommand.c actuator_Command.c actuator_Status.c
    ../Core/include/uavcan/protocol/dynamic_node_id/: dynamic_node_id_Allocation.c
    ../Core/include/uavcan/protocol/: protocol_NodeStatus.c protocol_GetNodeInfo.c protocol_HardwareVersion.c protocol_SoftwareVersion.c protocol_RestartNode.c protocol_GetTransportStats.c protocol_CANIfaceStats.c
    ../Core/include/uavcan/protocol/param/: param_Empty.c param_GetSet.c param_NumericValue.c param_Value.c param_ExecuteOpcode.c
    ../Core/include/uavcan/equipment/esc/: esc_RawCommand.c
    ../Core/include/uavcan/protocol/file/: file_BeginFirmwareUpdate.c file_Path.c file_Read.c file_Error.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
